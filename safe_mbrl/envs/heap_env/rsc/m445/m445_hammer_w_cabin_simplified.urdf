Commit message: Added the collision aware demo

File: safe_mbrl/envs/heap_env/rsc/m445/m445_hammer_w_cabin_simplified.urdf (robot description, URDF)
Before this commit: robot M445, 37 links, 36 joints
Links:
- link HAMMER: geometry visual mesh filename=meshes/IMPACT_HAMMER.dae
